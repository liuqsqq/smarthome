# Keil uVision project IrDAControl.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT83C5136 Atmel
  cpu: IRAM(0-0xFF) XRAM(0-0x2FF) IROM(0-0x7FFF) CLOCK(24000000) MODP2
  output: IrDAControl +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: IrDAControl.c IRM3638T.c uart.c utils.c
